options:
  parameters:
    author: M.Rinke / N. Menlik
    copyright: (c) M. Rinke
    description: Radio Backend for ZMQ server to UHD SDR, Assinged freq is 91,5 MHz
    generate_options: no_gui
    id: Audio_Test
    output_language: python
    title: THM Radio Backend
  states: {}

blocks:
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate*5
  states: {}
- name: radio_freq
  id: variable
  parameters:
    value: '91500000'
  states: {}
- name: radio_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '50e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.001'
    type: float
  states: {state: disabled}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2000'
    server: 'True'
    type: float
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '100000'
    center_freq0: radio_freq
    dev_addr: ''
    gain0: radio_gain
    samp_rate: samp_rate*10
    stream_args: peak=0.003906
    sync: none
    type: fc32
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_wfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [network_tcp_source_0, '0', audio_sink_0_0, '0']
- [zeromq_sub_source_0, '0', audio_sink_0, '0']
- [zeromq_sub_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
